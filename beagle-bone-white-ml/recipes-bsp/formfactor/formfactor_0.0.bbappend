FILESEXTRAPATHS_prepend_beagle-bone-white-ml := "${THISDIR}/${PN}:"
