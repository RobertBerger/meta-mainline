require u-boot-common.inc

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=0507cd7da8e7ad6d6701926ec9b84c95"

PV = "v2015.10"

SRCREV = "5ec0003b19cbdf06ccd6941237cbc0d1c3468e2d"
