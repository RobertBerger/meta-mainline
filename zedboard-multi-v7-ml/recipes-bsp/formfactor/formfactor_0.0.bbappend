FILESEXTRAPATHS_prepend_zedboard-multi-v7-ml := "${THISDIR}/${PN}:"
