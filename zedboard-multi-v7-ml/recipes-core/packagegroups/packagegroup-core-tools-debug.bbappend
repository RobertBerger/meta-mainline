RDEPENDS_${PN}_append = "\
    smem \
    crash \
    "
