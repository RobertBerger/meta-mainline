FILESEXTRAPATHS_prepend_wandboard-multi-v7-ml := "${THISDIR}/${PN}:"
