FILESEXTRAPATHS_prepend_phyboard-wega-am335x-1-ml := "${THISDIR}/${PN}:"
