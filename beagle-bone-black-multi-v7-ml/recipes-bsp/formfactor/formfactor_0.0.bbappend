FILESEXTRAPATHS_prepend_beagle-bone-black-multi-v7-ml := "${THISDIR}/${PN}:"
