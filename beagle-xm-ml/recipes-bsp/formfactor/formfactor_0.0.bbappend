FILESEXTRAPATHS_prepend_beagle-xm-ml := "${THISDIR}/${PN}:"
