RDEPENDS_${PN}_append = "\
    smem \
    crash \
    valgrind \
    procrank-linux \
    "
