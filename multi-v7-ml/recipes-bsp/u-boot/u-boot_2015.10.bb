# This is supposed to be only version dependent
require recipes-bsp/u-boot/u-boot-common.inc

PV = "v2015.10"
SRCREV = "5ec0003b19cbdf06ccd6941237cbc0d1c3468e2d"
