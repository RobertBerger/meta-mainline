require u-boot-common.inc

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=a2c678cfd4a4d97135585cad908541c6"

PV = "v2016.09"

# This is actualla v2016.09-rc2, but for now we'll leave it
# We'll fix the SRCREV once v2016.09 is released
SRCREV = "1d3bcb66ee90ff3ceff9da9b6501d08a915ea671"

# u-boot patches
# SRC_URI += "file://0001-enable-uEnv.txt_2016.01.patch"

